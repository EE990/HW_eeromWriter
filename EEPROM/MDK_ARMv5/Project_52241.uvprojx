# Keil uVision project Project_52241.uvprojx, settings and files
target HT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52241 Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IROM(0x00000000,0xFC00) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52241_SK, USE_HT32F52231_41
  c include: ..\;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F520xx\Include;..\library\HT32F520xx_Driver\inc;..\library\HT32_USBD_Library\inc;..\utilities
  asm define: USE_HT32_CHIP=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f520xx_01_it.c
  group Config
    ../: ht32f520xx_01_conf.h
    ./: ht32_op.s HT32F520xx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f520xx_02.c
  group MDK-ARM
    ./: startup_ht32f520xx_01.s
  group Library
    ../library/HT32F520xx_Driver/src/: ht32_cm0plus_misc.c ht32f520xx_adc.c ht32f520xx_bftm.c ht32f520xx_ckcu.c ht32f520xx_crc.c ht32f520xx_exti.c ht32f520xx_flash.c ht32f520xx_gpio.c ht32f520xx_i2c.c ht32f520xx_mctm.c ht32f520xx_pwrcu.c ht32f520xx_rstcu.c ht32f520xx_rtc.c ht32f520xx_spi.c ht32f520xx_tm.c ht32f520xx_usart.c ht32f520xx_wdt.c
  group Retarget
    ../library/HT32F520xx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
    ../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
