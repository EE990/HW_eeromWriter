# IAR project Project_52352.ewp, settings and files
configuration HT32 (ARM, debug)
  General.OGChipSelectEditMenu: HT32F52352 Holtek HT32F52352
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F52352_SK; USE_HT32F52342_52
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F520xx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F520xx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=4
  OBJCOPY.OOCOutputFile: HT32.hex
  ILINK.IlinkOutputFile: HT32.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_ht32f520xx_01.c
  group Config
    ./: ht32_op.c
    ../: ht32f520xx_01_conf.h ht32f523xx_01_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f520xx_01.s
  group Library
    ../../../../library/HT32F520xx_Driver/src/: ht32_cm0plus_misc.c ht32f520xx_adc.c ht32f520xx_bftm.c ht32f520xx_ckcu.c ht32f520xx_cmp.c ht32f520xx_crc.c ht32f520xx_ebi.c ht32f520xx_exti.c ht32f520xx_flash.c ht32f520xx_gpio.c ht32f520xx_i2c.c ht32f520xx_i2s.c ht32f520xx_mctm.c ht32f520xx_pdma.c ht32f520xx_pwrcu.c ht32f520xx_rstcu.c ht32f520xx_rtc.c ht32f520xx_sci.c ht32f520xx_spi.c ht32f520xx_tm.c ht32f520xx_usart.c ht32f523xx_usbd.c ht32f520xx_wdt.c
  group Retarget
    ../../../../library/HT32F520xx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ../: ht32f520xx_01_it.c main.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
