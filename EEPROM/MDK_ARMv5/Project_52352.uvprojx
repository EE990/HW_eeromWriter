# Keil uVision project Project_52352.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.3
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: HT32 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F520xx\Include;..\..\..\..\library\HT32F520xx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f520xx_01_it.c
  group Config
    ../: ht32f520xx_01_conf.h ht32f523xx_01_usbdconf.h
    ./: ht32_op.s HT32F520xx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f520xx_01.c
  group MDK-ARM
    ./: startup_ht32f520xx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F520xx_Driver/src/: ht32_cm0plus_misc.c ht32f520xx_adc.c ht32f520xx_bftm.c ht32f520xx_ckcu.c ht32f520xx_cmp.c ht32f520xx_crc.c ht32f520xx_ebi.c ht32f520xx_exti.c ht32f520xx_flash.c ht32f520xx_gpio.c ht32f520xx_i2c.c ht32f520xx_i2s.c ht32f520xx_mctm.c ht32f520xx_pdma.c ht32f520xx_pwrcu.c ht32f520xx_rstcu.c ht32f520xx_rtc.c ht32f520xx_sci.c ht32f520xx_spi.c ht32f520xx_tm.c ht32f520xx_usart.c ht32f523xx_usbd.c ht32f520xx_wdt.c
  group Retarget
    ../../../../library/HT32F520xx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
